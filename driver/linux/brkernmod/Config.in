## driver/linux/brkernmod/Config.in
```kconfig
config BR2_PACKAGE_BRKERNMOD
	bool "Enable Hafnium Kernel Module"
	default y
	help
	  Cross your fingers and hope this works
```
